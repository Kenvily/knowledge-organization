# Keil uVision project Recording Room.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\pwm;..\SYSTEM\adc;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\MIDDLEWARE\MALLOC;..\MIDDLEWARE\FreeRTOS\include;..\MIDDLEWARE\FreeRTOS\portable\MemMang;..\MIDDLEWARE\FreeRTOS\portable\RVDS\ARM_CM3;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\BUZZER;..\HARDWARE\DHT11;..\HARDWARE\RTC;..\HARDWARE\SERVO;..\HARDWARE\RELAY;..\HARDWARE\GASE;..\HARDWARE\DECIBEL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s system_stm32f1xx.c stm32f1xx_it.c
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/pwm/: pwm.c
    ../SYSTEM/adc/: adc.c
  group MIDDLEWARE
    ../MIDDLEWARE/MALLOC/: malloc.c
    ../MIDDLEWARE/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MIDDLEWARE/FreeRTOS/portable/MemMang/: heap_4.c
    ../MIDDLEWARE/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/GASE/: gase.c
    ../HARDWARE/DECIBEL/: decibel.c
  group USER
    ./: main.c freertos_demo.c
  group README
    ../: readme.txt
